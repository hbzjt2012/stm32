<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F769I-DISCO_CoreMark.ewp</path>
  </project>
  <batchBuild />
</workspace>
